BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing the Missile with Wing Models for Robustmess Analysis
! This batch set creates a Missile with Wing Model that includes 24 uncertainties.
! Then it separates it in two smaller systems: a Pitch system with 8 uncertainties, 
! and a Lateral system with 16 uncertainties.
! 
Flight Vehicle   : Missile with Wing with 24 Uncertainties
System Modificat : Missile with Wing Lateral Model with 16 Uncertainties
Transf-Function  : Wind Gust Shaping Function
Transf-Function  : Lateral Flight Control System (Classical Design)
To Matlab Format : Missile with Wing Lateral Model with 16 Uncertainties 
To Matlab Format : Lateral Flight Control System (Classical Design)
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Missile with Wing with 24 Uncertainties 
! This is a rgid-body model of an accelerating missile with a wing. The engine 
! is not included in the model because it is neither gimbaling nor throttling.
! This vehicle model generates additional inputs and outputs which represent
! internal parameter uncertainties using the IFL method. The uncertainties data 
! are included in a separate data-set below the vehicle data.
!
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   1219.1,      32.07,      0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.40631E+04  0.16542E+06 0.1659E+06    24.0  -521.0   0.0 
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   26.19,       0.0,       -0.15
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   2.5,         2427.4,     1220.6,       50000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   60.0,        60.0,       0.0,          10.5
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   10.5,        0.0,        0.0,          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0,         39.6,       0.0,          0.0,   0.132,  0.0     
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0        90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   145.4,       22.0,       22.0    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   26.19,       0.0,       -0.238,          0.0 
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.1,    0.002,  0.0,   0.0,     0.0,     0.0,  0.0 
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0,   -0.023,  0.0,   0.0,     0.0,     0.0,  0.0     
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.1,   -0.032,  0.0,   0.0,     0.0,     0.0,  0.0
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0,   -0.0017, 0.0,  -0.243,   0.1329,  0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.037, -0.011,  0.0,   0.0,     0.03,    0.0,  0.0
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0,  5.693e-4, 0.0,   0.1388,  -2.525,  0.0         

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  3   No TWD

Control Surface No:  1                                                                     Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00003     -0.0         -0.0087        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0         -0.0072       0.0           0.0000       0.0000       0.0000    

Control Surface No:  2                                                                     Aileron    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00003      0.0011       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -6.5406e-4    0.0         -0.0014        0.0000       0.0000       0.0000    

Control Surface No:  3                                                                     Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00001      0.0034       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  5.9456e-4    0.0         -0.0035        0.0000       0.0000       0.0000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No 1 Axis:(X,Y,Z), (Position,Velocity,Accelerat), Location in (feet)         :  Y-axis Acceleration     46.3, 0.0, -0.05
Acceleromet No 2 Axis:(X,Y,Z), (Position,Velocity,Accelerat), Location in (feet)         :  Z-axis Acceleration     46.3, 0.0, -0.05

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  1
Vane No 1 Location in Vehicle Axes  (feet)                                               :  53.0, 0.0, 0.0

Parameter Uncertainties Data
Missile Uncertainties at Mach=2.5, Alpha=10

Number of Bending Modes                                                                  :  0
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......                                                                    
Missile Uncertainties at Mach=2.5, Alpha=10
! The following data are not actual vehicle parameters but they represent uncertainties
! of the corresponding parameters of the vehicle above. The title above these comments                                                                                
! defines the flight condition where they apply. The uncertainty values represent a +ve 
! or -ve additive variation above or below the nominal values shown in the vehicle data.
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.0          0.0          0.0                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  300.0        0.4e+4       0.4e+4       0.0   0.0    0.0                                                       
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  0.5          0.0          0.0                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.0          0.0          0.0          0.0                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  0.0          0.0          0.0          0.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  0.0          0.0          0.0          0.0                                                                        
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          0.0          0.0          0.0   0.0    0.0                                                       
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.0,    0.0,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,   0.008,   0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.05,  0.004,   0.0,   0.0,     0.0,     0.0,    0.0                                            
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,  0.0005,   0.0,   0.05,    0.05,    0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.01,  0.003,   0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,  1.0e-4,   0.0,   0.05,    0.5,     0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, (Variations from Nominal Aero Parameters)                    :  3                                                                                                    
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Elevon                                          
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0          0.0025        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0          0.0015       0.0           0.0          0.0          0.0    
Control Surface No:  2                                                                     Aileron
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0005      -0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  1.5e-4       0.0          0.0006        0.0          0.0          0.0    
Control Surface No:  3                                                                     Rudder                                                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.001        0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  1.5e-4       0.0          0.0012        0.0          0.0          0.0    
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Missile with Wing Lateral Model with 16 Uncertainties
Missile with Wing with 24 Uncertainties                       
! The lateral system and lateral uncertainties are extracted from the 
! coupled RB system. Notice the Xcg is a rank-2 uncertainty creating two
! inputs and two outputs. The first i/o pair is selected because it affects 
! the lateral dynamics
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2  3  4                   5  7  9 12 13 14 15 16 18 19 23 24 25 26 27 28
Extract States :   1  2  5  6  8
Extract Outputs:   1  2  5  6  8 11 12 15   16 18 20 23 24 25 26 27 29 30 34 35 36 37 38 39
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Wind Gust Shaping Function
Continuous
TF. Block #  1  0.8^2/(s^2 +0.5s +0.8^2)                         Order of Numer, Denom=  0  2
Numer 0.0         0.0        0.48
Denom 1.0         0.7        0.48
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Lateral Flight Control System (Classical Design)
! This FCS was design using classical control methods
Continuous
TF. Block #  1 Low Pass x1                                       Order of Numer, Denom=  0  1
Numer 0.0         20.0                                           p and r inputs
Denom 1.0         20.0
TF. Block #  2 Low Pass x2                                       Order of Numer, Denom=  0  1
Numer 0.0         2.0                                            g cos(theta) phi + Ny
Denom 1.0         2.0
TF. Block #  3 Low Pass x3                                       Order of Numer, Denom=  0  1
Numer 0.0         5.0                                            d_ail + d_rudd
Denom 1.0         10.0
TF. Block #  4 Vy estimate x4                                    Order of Numer, Denom=  0  1
Numer 0.0         1.0                                            -20x1 + 2x2 + 5x3
Denom 1.0         0.5
TF. Block #  5 Low Pass x5                                       Order of Numer, Denom=  0  1
Numer 0.0         0.5                                            from aileron summing junct.
Denom 1.0         0.5
TF. Block #  6 Low Pass x6                                       Order of Numer, Denom=  0  1
Numer 0.0         1.0                                            
Denom 1.0         5.0
TF. Block #  6 Low Pass x7                                       Order of Numer, Denom=  0  1
Numer 0.0         1.0                                            
Denom 1.0         5.0
TF. Block #  7 Integrator x8                                     Order of Numer, Denom=  0  1
Numer 0.0         1.0                                            Xi_error Integral
Denom 1.0         0.0
......................................................
Block #, from Input #, Gain
 1       1   -7.7347756                                          p (deg)     to TF#1
 1       4    41.652282                                          r (deg)     to TF#1
 2       2    0.43205625                                         phi (deg)   to TF#2
 2       6    1.0                                                Ny          to TF#2
 3       6   -11.458                                             Ny          to TF#3
 3       7    1.8531                                             d_ailr_meas to TF#3
 3       8    5.9025                                             d_rudd_meas to TF#3
 8       3    1.0                                                Xi_cmd      to TF#8
 8       5   -1.0                                                psi         to TF#8
 5       3    0.38397                                            Xi_cmd      to TF#5
 5       5   -0.384007342                                        psi         to TF#5
 5       1   -0.100523984                                        p           to TF#5
 7       1    0.004537856                                        p           to TF#7
 7       2    0.005235988                                        phi         to TF#7
...........................
Block #, from Block #, Gain
 4       1   -1.0                                                TF#1  to  TF#4
 4       2    1.0                                                TF#2  to  TF#4
 4       3    1.0                                                TF#3  to  TF#4
 5       8    0.019199                                           TF#8  to  TF#5
 5       4   -9.0637e-3                                          TF#4  to  TF#5
 6       4   -4.25e-4                                            TF#4  to  TF#6
 6       1    3.5e-4                                             TF#1  to  TF#6
 6       2   -3.5e-4                                             TF#2  to  TF#6
 6       3   -3.5e-4                                             TF#3  to  TF#6
 8       4   -0.023605                                           TF#4  to  TF#8 beta_estim
 7       5   -0.3                                                TF#5  to  TF#7 
...........................
Outpt #, from Block #, Gain
 1       5   -8.595                                              TF#5  to  (dail)
 1       7    143.25                                             TF#7  to  (dail)
 2       6    143.25                                             TF#6  to  (drud)
 2       4   -0.012176                                           TF#4  to  (drud)
 2       1    0.0100275                                          TF#1  to  (drud)
 2       2   -0.0100275                                          TF#2  to  (drud)
 2       3   -0.0100275                                          TF#3  to  (drud)
...........................
Outpt #, from Input #, Gain
 1       1    0.1300095                                          p    to (dail)
 1       2    0.150011                                           phi  to (dail)
...........................
Definitions of Inputs  =   8
Roll Rate       (rad/sec)                                            
Roll  Attitude  (radians)                                            
Flight Direction Command, Xi_cmd (deg)                                            
Yaw  Rate       (rad/sec)                                            
Yaw   Attitude  (radians)                                            
Lateral Accelerometer at IMU (ft/sec^2)
Aileron Actuator Deflection Measured (deg)
Rudder  Actuator Deflection Measured (deg)
 
Definitions of Outputs =   2
Aileron Actuator Command (deg)
Rudder  Actuator Command (deg)
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Missile with Wing Lateral Model with 16 Uncertainties
System
vehi_later_unc.m
------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral Flight Control System (Classical Design)
System
later_fcs_class.m
------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
