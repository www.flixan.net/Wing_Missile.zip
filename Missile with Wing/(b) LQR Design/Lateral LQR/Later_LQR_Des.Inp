BATCH MODE INSTRUCTIONS ...............                                                             
Batch for Designing Pitch Models and Gains for a Missile with Wing 
!
! This batch set creates the Design and Analysis models for a
! Missile with Wing at 2.5 Mach, and performs LQR design. 
! The Missile has a fixed Thrust and it is controlled by 3 Aerosurfaces
!
!                  Control Design Matrices
Retain Matrix    : State Weight Matrix Qc (9x9) 
Retain Matrix    : Control Weight Matrix Rc (2x2) 
!
Flight Vehicle   : Missile with Wing, Mach: 2.5, Qbar: 1220   
System Modificat : Missile with Wing Lateral Design Model  
System Modificat : Missile with Wing Lateral Analysis Model   
Transf-Functions : Actuator: 34/(s+34)
Transf-Functions : Integrator    
System Connection: Augmented Lateral Design Model
System Modificat : Augmented Lateral Design Model-2
LQR Control Des  : LQR Control Design for Augmented Lateral Design Model
!
!                  Convert to Matlab
To Matlab Format : Missile with Wing Lateral Analysis Model 
To Matlab Format : LQR State-Feedback Control for Augmented Lateral Design Model
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Missile with Wing, Mach: 2.5, Qbar: 1220         
! Rigid-Body Missile controlled by 3 aerosurfaces. The engine has fixed thrust
! and does not gimbal
!
Body Axes Output, Attitude=Euler Angles, NoWind Alpha
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   1219.1,      32.07,      0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.40631E+04  0.16542E+06 0.1659E+06    24.0  -521.0   0.0 
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   26.19,       0.0,       -0.15
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   2.5,         2427.4,     1220.6,       50000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   60.0,        60.0,       0.0,          10.5
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   10.5,        0.0,        0.0,          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0,         39.6,       0.0,          0.0,   0.132,  0.0     
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         90.0        90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   145.4,       22.0,       22.0    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   26.19,       0.0,       -0.238,          0.0 
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.1,    0.002,  0.0,   0.0,     0.0,     0.0,  0.0 
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0,   -0.023,  0.0,   0.0,     0.0,     0.0,  0.0     
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  -0.1,   -0.032,  0.0,   0.0,     0.0,     0.0,  0.0
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0,   -0.0017, 0.0,  -0.243,   0.1329,  0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -0.037, -0.011,  0.0,   0.0,     0.03,    0.0,  0.0
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0,  5.693e-4, 0.0,   0.1388,  -2.525,  0.0         

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  3   No TWD

Control Surface No:  1                                                                     Elevator    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00003     -0.0         -0.0087        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0         -0.0072       0.0           0.0000       0.0000       0.0000    

Control Surface No:  2                                                                     Aileron    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00003      0.0011       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -6.5406e-4    0.0         -0.0014        0.0000       0.0000       0.0000    

Control Surface No:  3                                                                     Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000        0.000        0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0   
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00001      0.0034       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  5.9456e-4    0.0         -0.0035        0.0000       0.0000       0.0000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No 1 Axis:(X,Y,Z), (Position,Velocity,Accelerat), Location in (feet)         :  Y-axis Acceleration     46.3, 0.0, -0.05
Acceleromet No 2 Axis:(X,Y,Z), (Position,Velocity,Accelerat), Location in (feet)         :  Z-axis Acceleration     46.3, 0.0, -0.05

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  1
Vane No 1 Location in Vehicle Axes  (feet)                                               :  53.0, 0.0, 0.0

Number of Bending Modes                                                                  :  0

------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Missile with Wing Lateral Design Model                                                                                            
Missile with Wing, Mach: 2.5, Qbar: 1220                 
! The initial Lateral Design system is extracted from the coupled RB system above     
!                                
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2   3   
Extract States :   1   2   5   6   8
Extract Outputs:   1   2   5   6   8  
-------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Missile with Wing Lateral Analysis Model                                                                                            
Missile with Wing, Mach: 2.5, Qbar: 1220                
! The lateral Analysis/ Simulation system is extracted from the coupled RB system above     
!                                
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2   3   4
Extract States :   1   2   5   6   8
Extract Outputs:   1   2   5   6   8  11  12  15
-------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Actuator: 34/(s+34)
! First order Actuator 34 (rad/sec) Bandwidth
Continuous
TF. Block #  1 34/(s+34)                                         Order of Numer, Denom=  0  1
Numer 0.0         34.0
Denom 1.0         34.0
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    1.00000
...........................
Outpt #, from Block #, Gain
  1  1    1.00000
...........................
Definitions of Inputs  =   1
Delta Command                                                                
 
Definitions of Outputs =   1
Delta Out                                                
-------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Integrator
Continuous
TF. Block #  1  (1/s)                                           Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    1.00000
...........................
Outpt #, from Block #, Gain
  1  1    1.00000
...........................
-------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Augmented Lateral Design Model
! Create a 9-State Augmented Model that Includes Phi-integr, Psi-integr, 
! aileron and rudder deflections in the state vector for Lateral Control Design
!
Titles of Systems to be Combined   
Title 1 Actuator: 34/(s+34)
Title 2 Actuator: 34/(s+34)
Title 3 Missile with Wing Lateral Design Model 
Title 4 Integrator
Title 5 Integrator
SYSTEM INPUTS TO SUBSYSTEM  1                                                          to Ailern Actuator
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   Delta-ailer Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                          to Rudder Actuator
System Input  2 to Subsystem  2, Input  1, Gain= 1.0                                   Delta-ruddr Command
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                       Vehicle Plant
System Output  1 from Subsystem  3, Output  1, Gain= 1.0                               Phi
System Output  2 from Subsystem  3, Output  2, Gain= 1.0                               p - roll rate
System Output  3 from Subsystem  3, Output  3, Gain= 1.0                               Psi
System Output  4 from Subsystem  3, Output  4, Gain= 1.0                               r - yaw rate
System Output  5 from Subsystem  3, Output  5, Gain= 1.0                               Beta
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                       Integrator
System Output  6 from Subsystem  4, Output  1, Gain= 1.0                               Phi-integral
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                       Integrator
System Output  7 from Subsystem  5, Output  1, Gain= 1.0                               Psi-integral
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                       Actuator
System Output  8 from Subsystem  1, Output  1, Gain= 0.0294118                         delta-aileron
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Actuator
System Output  9 from Subsystem  2, Output  1, Gain= 0.0294118                         delta-rudder
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                                Ailer-Actuat to Vehicle                                         
Subsystem  1, Output  1 to Subsystem  3, Input  1, Gain=   1.0000                      Aileron-deflect          
......................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                Ruddr-Actuat to Vehicle                                         
Subsystem  2, Output  1 to Subsystem  3, Input  2, Gain=   1.0000                      Rudder-deflect          
......................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  4                                                Vehicle to Integrator-4                                    
Subsystem  3, Output  1 to Subsystem  4, Input  1, Gain=   1.0000                      Phi 
......................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  5                                                Vehicle to Integrator-4                                    
Subsystem  3, Output  3 to Subsystem  5, Input  1, Gain=   1.0000                      Psi 
......................................................................
Definitions of Inputs  =   2
Aileron Deflection Command (delta) rad
Rudder  Deflection Command (delta) rad

Definitions of Outputs =   9
Roll Attitude, Phi (rad)
Roll Rate, p (rad/sec)
Yaw  Attitude, Psi (rad)
Yaw  Rate, r (rad/sec)
Angle of Sideslip beta (rad)
Phi-Integral (rad-sec)
Psi-Integral (rad-sec)
Aileron Deflection, delta-ailer (rad)
Rudder Deflection, delta-rudder (rad)
-------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Augmented Lateral Design Model-2
Augmented Lateral Design Model
! Rearange the Order of States to be the same as the Outputs
! Makes C=Identity
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract States :   3   4   5   6   7   8   9   1   2
Extract Outputs:   1   2   3   4   5   6   7   8   9
----------------------------------------------------------------------------------------------------
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
LQR Control Design for Augmented Lateral Design Model                                                                                                                                      
Plant Model Used to Design the Control System from:        Augmented Lateral Design Model-2                                                                                                             
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc9                 State Weight Matrix Qc (9x9)                                                                                                                 
Control Penalty Weight (Rc) is Matrix: Rc2                 Control Weight Matrix Rc (2x2)                                                                                                               
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kpr                 LQR State-Feedback Control for Augmented Lateral Design Model                                                                        
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
LQR State-Feedback Control for Augmented Lateral Design Model
Matrix Kpr
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Missile with Wing Lateral Analysis Model
System
Vehi_lateral.m
-------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
